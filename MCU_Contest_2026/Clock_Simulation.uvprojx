# Keil uVision project Clock_Simulation.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Clock_Simulation +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MOCK_SIMULATION
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main_clock_skeleton.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
